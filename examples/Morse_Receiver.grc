options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: gr_Morse_Receiver
    output_language: python
    title: gr_Morse_Receiver
  states: {}

blocks:
- name: freq_morse
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '7000000'
    step: '1'
    stop: '7040000'
    value: '7000000'
  states: {}
- name: freq_shift_corr
  id: variable
  parameters:
    comment: |-
      to match signals found
      in spectrum analysers
    value: '-602.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: signal gain
    label: Gain
    start: '25'
    step: '1'
    stop: '1000'
    value: '450'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: thresholder high
    label: high_thres
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: thresholder low
    label: low_thres
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: loudness
  id: variable_qtgui_range
  parameters:
    comment: |-
      avoid listening to
      loud clipped signals
    label: loudness
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      filter out low noise
      below given threshold
    threshold: '-110'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      listening live to 
      Morse symbols
    samp_rate: '24000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: |-
      avery dense filter
      to pick up just one
      Morse signal
    decim: '8'
    gain: '15'
    high_cutoff_freq: '805'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '400'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: loudness
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide whether
      the received signal
      is on or off
    high: hi_thres
    init: '0'
    low: lo_thres
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    ASCII_pause: '650'
    OOK_pause: '240'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      # counts number of ones of current status
      _num_ones  = 0

      # counts number of zeros of current status
      _num_zeros = 0

      # stores current on/off status
      _sync = -1


      class blk(gr.sync_block):

          def __init__(self, OOK_pause=270, ASCII_pause=825, short_sym=280, long_sym=870, break_pause=1200, tolerance=40, debug=False, verbose=True):

              gr.sync_block.__init__(
                  self,
                  name='Morse Decoder',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
              # durations of the symbols and pauses
              self.tolerance   = tolerance
              self.OOK_pause   = OOK_pause
              self.ASCII_pause = ASCII_pause
              self.short_sym   = short_sym
              self.long_sym    = long_sym
              self.break_pause = break_pause

              # verbose/debug output
              self.debug       = debug
              self.verbose     = verbose

              if self.verbose == True:
                  print("tolerance: ", self.tolerance)
                  print("OOK pause: ", self.OOK_pause)
                  print("ASCII pause: ", self.ASCII_pause)
                  print("short sym: ", self.short_sym)
                  print("long sym: ", self.long_sym)
                  print("break: ", self.break_pause)

              # output message
              self.message_port_register_out(pmt.intern('msg_out'))
              

          def work(self, input_items, output_items):
              global _num_zeros
              global _num_ones
              global _sync

              inp = input_items[0]

              for idx in range(len(inp)):
                  ch = inp[idx]

                  if ch == 1:
                      _num_ones += 1

                  else: # ch == 0
                      _num_zeros += 1

                  # out of sync status
                  if _sync == -1:
                      _num_zeros = 0
                      _num_ones = 0

                      if ch == 0:
                          _sync = 0
                          if self.debug:
                              print("sync 0")
                      
                      elif ch == 1:
                          _sync = 1
                          if self.debug:
                              print("sync 1")
                  
                  # status: currently off
                  elif _sync == 0:
                      # status remains identical
                      if ch == 0:
                          pass
                      
                      elif ch == 1:
                          _sync = 1
                          # WARN: this print is very slow, and may cause GNURadio to crash
                          #print(f"sync 1: #zeros: {_num_zeros}")

                          # detect OOK pause
                          if (_num_zeros >= self.OOK_pause - self.tolerance and
                              _num_zeros <= self.OOK_pause + self.tolerance):
                              
                              if self.debug:
                                  #print(f"OOK pause")
                                  pass

                              # marking detected OOK_pause
                              key = pmt.intern(" ")
                              value = pmt.intern("OOK_pause")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect ASCII pause
                          elif (_num_zeros >= self.ASCII_pause - self.tolerance and
                              _num_zeros <= self.ASCII_pause + self.tolerance):
                              
                              if self.verbose:
                                  print("")
                                  #print(f"symbol end")

                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern(" "))

                              # marking detected ASCII pause
                              key = pmt.intern(" ")
                              value = pmt.intern("ASCII_pause")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect break pause
                          elif (_num_zeros >= self.break_pause - self.tolerance):
                              
                              if self.verbose:
                                  print("")
                                  #print(f"symbol end, break")
                                  
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern(";"))
                              
                              # marking detected break pause
                              key = pmt.intern(" ")
                              value = pmt.intern("break_pause")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          _num_zeros = 0
                  
                  # status: currently on
                  elif _sync == 1:
                      # status changes
                      if ch == 0:
                          _sync = 0
                          # WARN: this print is very slow, and may cause GNURadio to crash
                          #print(f"sync 0: #ones: {_num_ones}")
                          
                          # detect short symbol
                          if (_num_ones >= self.short_sym - self.tolerance and
                              _num_ones <= self.short_sym + self.tolerance):
                              
                              if self.verbose:
                                  print(f".", end="")
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern("."))

                              # marking detected short symbol
                              key = pmt.intern(".")
                              value = pmt.intern(".")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect long symbol
                          elif (_num_ones >= self.long_sym - self.tolerance and
                                _num_ones <= self.long_sym + self.tolerance):
                              
                              if self.verbose:
                                  print(f"_", end="")
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern("_"))

                              # marking detected long symbol
                              key = pmt.intern("_")
                              value = pmt.intern("_")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          _num_ones = 0

                      # status remains identical
                      elif ch == 1:
                          pass
                  
                  # reset zeros during longer pauses
                  if _num_zeros >= 200000:
                      _sync = -1
                      _num_zeros = 0
                      _num_ones = 0

                  # this should not happen anyway
                  if _num_ones >= 200000:
                      _sync = -1
                      _num_zeros = 0
                      _num_ones = 0

              # simply pass through original signal with tags attached
              output_items[0][:] = input_items[0]

              return len(output_items[0])
    break_pause: '930'
    comment: |-
      determines the morse
      symbols ".", "_", and
      symbol/word breaks
      with a certain tolerance
    debug: 'False'
    long_sym: '700'
    short_sym: '240'
    tolerance: '150'
    verbose: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      several (mostly German) websites on Morse code and acronyms

      http://dk3red.homepage.t-online.de/de/s3_02.htm
      http://dk3red.homepage.t-online.de/de/s3.htm
      https://wiki.oevsv.at/wiki/Abk%C3%BCrzungen
      https://www.modellskipper.de/Maritimes/Abkuerzungen_Abschnitt_A/Index
      https://www.qsl.net/dk5ke/abk.html
      https://wiki.edu.vn/wiki18/2021/01/26/abkurzungen-fur-morsecodes-wikipedia/

      https://en.wikipedia.org/wiki/Morse_code_abbreviations
    note: Morse Abbreviations (German Translation)
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      35.7 – 137,8 kHz
      1810 – 1838 kHz
      3500 – 3570 kHz
      7000 – 7040 kHz
      10100 – 10130 kHz
      14000 – 14070 kHz
      18068 – 18095 kHz
      21000 – 21070 kHz
      24890 – 24915 kHz
      28000 – 28070 kHz
    note: permitted Morse frequencies
  states: {}
- name: note_1_0
  id: note
  parameters:
    comment: |-
      270
      825
      270
      825
      1200
      150
    note: slower Morse parameters
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    comment: |-
      240
      650
      240
      700
      930
      150
    note: faster Morse parameters
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: '10000'
    freq0: freq_morse + freq_shift_corr
    gain0: '5'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      to adjust the
      thresholder
    label1: received signal
    label2: threshold signal
    nconnections: '2'
    size: int(samp_rate/8)
    srate: int(samp_rate/32)
    type: float
    ymax: '6'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1000'
    comment: |-
      helps the user to
      find and adjust
      active Morse
      signals
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      especially to
      avoid overflows
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ server
      to futher decode the symbols
      to human-readible ASCII
      symbols and words
    timeout: '900'
  states: {}

connections:
- [analog_simple_squelch_cc_0_0, '0', blocks_multiply_const_xx_0, '0']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', audio_sink_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0_0, msg_out, zeromq_push_msg_sink_1, in]
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_threshold_ff_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
