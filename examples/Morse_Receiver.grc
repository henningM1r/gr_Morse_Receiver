options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: gr_Morse_Receiver
    output_language: python
    title: gr_Morse_Receiver
  states: {}

blocks:
- name: band_freq
  id: variable
  parameters:
    value: '7000000'
  states: {}
- name: check_box_print_0duration
  id: variable_qtgui_msgcheckbox
  parameters:
    comment: |-
      enable printing the duration
      of OFF signal in the console
      of GNURadio Companion
    gui_hint: (22,2)
    initPressed: 'False'
    label: Print durations of OFF
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: checkbox_print_1duration
  id: variable_qtgui_msgcheckbox
  parameters:
    comment: |-
      enable printing the duration
      of ON signal in the console
      of GNURadio Companion
    gui_hint: (22,1)
    initPressed: 'False'
    label: Print durations of ON
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: checkbox_print_symbols
  id: variable_qtgui_msgcheckbox
  parameters:
    comment: |-
      enable printing received
      symbols in the console
      of GNURadio Companion
    gui_hint: (22,0)
    initPressed: 'False'
    label: Print Symbols
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: element_space
  id: variable_qtgui_range
  parameters:
    gui_hint: (19,0,1,3)
    label: element_space
    start: '80'
    step: '1'
    stop: '700'
    value: '270'
  states: {}
- name: freq_morse
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,3)
    label: Frequency
    start: '0'
    step: '1'
    stop: '100000'
    value: '0'
  states: {}
- name: freq_shift_corr
  id: variable
  parameters:
    comment: |-
      to match signals found
      in spectrum analysers
    value: '400'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: signal gain
    gui_hint: (4,0,1,3)
    label: Gain
    start: '15'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: thresholder high
    gui_hint: (10,0,1,3)
    label: high_thres
    start: '0.01'
    step: '0.1'
    stop: '20'
    value: '1'
  states: {}
- name: label1
  id: variable_qtgui_label
  parameters:
    gui_hint: (23, 0)
    label: 'Note: Please view detected Morse symbols in gr-companion console (set -print symbols- checked)'
    type: string
    value: ''
  states: {}
- name: label2
  id: variable_qtgui_label
  parameters:
    gui_hint: (24, 0)
    label: 'Note: Please run DecodeMorse.py in a terminal to view decoded Morse symbols as ASCII symbols'
    type: string
    value: ''
  states: {}
- name: label3
  id: variable_qtgui_label
  parameters:
    gui_hint: (2,0,1,3)
    label: 'CW-bands: 7000000, 14000000, 18068000, 21000000'
    type: string
    value: ''
  states: {}
- name: letter_space
  id: variable_qtgui_range
  parameters:
    gui_hint: (20,0,1,3)
    label: letter_space
    start: '200'
    step: '1'
    stop: '1600'
    value: 270*3
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: thresholder low
    gui_hint: (11,0,1,3)
    label: low_thres
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '0.07'
  states: {}
- name: long_mark
  id: variable_qtgui_range
  parameters:
    gui_hint: (18,0,1,3)
    label: long_mark
    start: '200'
    step: '1'
    stop: '1600'
    value: 270*3
  states: {}
- name: loudness
  id: variable_qtgui_range
  parameters:
    comment: |-
      avoid listening to
      loud clipped signals
    gui_hint: (0,0,1,3)
    label: loudness
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: print_0duration
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: print_1duration
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: print_symbols
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: short_mark
  id: variable_qtgui_range
  parameters:
    gui_hint: (17,0,1,3)
    label: short_mark
    start: '80'
    step: '1'
    stop: '700'
    value: '270'
  states: {}
- name: tolerance
  id: variable_qtgui_range
  parameters:
    comment: duration tolerance range
    gui_hint: (15,0,1,3)
    label: tolerance
    start: '50'
    step: '1'
    stop: '200'
    value: '100'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '200'
    gain: '15'
    samp_rate: samp_rate
    width: '200'
    win: window.WIN_BLACKMAN
  states: {}
- name: word_space
  id: variable_qtgui_range
  parameters:
    gui_hint: (21,0,1,3)
    label: word_space
    start: '800'
    step: '1'
    stop: '8000'
    value: 270*7
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: gain
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: hi_thres
    comment: |-
      high threshold line
      in time plot
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: lo_thres
    comment: |-
      low threshold line
      in time plot
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      filter out very low noise
      below given threshold
    threshold: '-110'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      listening live to received
      Morse tones
    samp_rate: '24000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    comment: write to variable
    target: print_symbols
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: write to variable
    target: print_1duration
  states: {}
- name: blocks_msgpair_to_var_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: write to variable
    target: print_0duration
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    comment: write to variable
    target: band_freq
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      Scale signal according
      to gain slider
    const: '15'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: loudness
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide whether
      the received signal
      is on or off
    high: hi_thres
    init: '0'
    low: lo_thres
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr



      class blk(gr.sync_block):

          def __init__(self, threshold=0.0, mode=0, coeff=0.15):
              gr.sync_block.__init__(
                  self,
                  name='Envelope Detector',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.ry = 0
              self.threshold = threshold
              self.mode = mode
              self.coeff = coeff


          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]

              buf = [0] * len(input_items[0])
              a0 = self.coeff
              b1 = 1 - a0

              for i in range(0, len(input_items[0])):
                  if self.mode == 1:
                      buf[i] = abs(input_items[0][i])
                  else:
                      if input_items[0][i] > self.threshold:
                          buf[i] = input_items[0][i]
                      else:
                          buf[i] = 0

              for i in range(0, len(input_items[0])):
                  if i == 0:
                      output_items[0][i] = a0*buf[i] + b1*self.ry
                  else: # i >= 1 
                      output_items[0][i] = a0*buf[i] + b1*output_items[0][i-1]

              i = len(output_items[0]) - 1
              self.ry = output_items[0][i]

              return len(output_items[0])
    coeff: '0.2'
    comment: |-
      smooth signal with
      an envelope detector
    mode: '0'
    threshold: '0.0'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    ASCII_pause: long_mark
    OOK_pause: short_mark
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      # counts number of ones of current status
      _num_ones  = 0

      # counts number of zeros of current status
      _num_zeros = 0

      # stores current on/off status
      _sync = -1


      class blk(gr.sync_block):

          def __init__(self, OOK_pause=270, ASCII_pause=825, short_sym=280, long_sym=870, break_pause=1200, tolerance=40, print_symbols=True, print_1duration=False, print_0duration=False):

              gr.sync_block.__init__(
                  self,
                  name='Morse Detector',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
              # durations of the symbols and pauses
              self.tolerance   = tolerance
              self.OOK_pause   = OOK_pause
              self.ASCII_pause = ASCII_pause
              self.short_sym   = short_sym
              self.long_sym    = long_sym
              self.break_pause = break_pause

              # verbose output
              self.print_symbols   = print_symbols
              self.print_1duration = print_1duration
              self.print_0duration = print_0duration

              if self.print_symbols == True:
                  print("short mark (.): ", self.short_sym)
                  print("long mark (_): ", self.long_sym)
                  print("element-space (^)", self.OOK_pause)
                  print("letter-space (~): ", self.ASCII_pause)
                  print("word-space (;): ", self.break_pause)
                  print("tolerance: ", self.tolerance)
                  

              # output message
              self.message_port_register_out(pmt.intern('msg_out'))
              

          def work(self, input_items, output_items):
              global _num_zeros
              global _num_ones
              global _sync

              inp = input_items[0]

              for idx in range(len(inp)):
                  ch = inp[idx]

                  if ch == 1:
                      _num_ones += 1

                  else: # ch == 0
                      _num_zeros += 1

                  # out of sync status
                  if _sync == -1:
                      _num_zeros = 0
                      _num_ones = 0

                      if ch == 0:
                          _sync = 0
                      
                      elif ch == 1:
                          _sync = 1
                  
                  # status: currently off
                  elif _sync == 0:
                      # status remains identical
                      if ch == 0:
                          pass
                      
                      elif ch == 1:
                          _sync = 1
                          # WARN: this print is very slow, and may cause GNURadio to crash
                          if self.print_0duration:
                              print(f"#zeros: {_num_zeros}")

                          # detect OOK pause
                          if (_num_zeros >= self.OOK_pause - self.tolerance and
                              _num_zeros <= self.OOK_pause + self.tolerance):
                              
                              if self.print_symbols:
                                  #print(f"^")
                                  pass

                              # marking detected OOK_pause
                              key = pmt.intern(" ")
                              value = pmt.intern("^")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect ASCII pause
                          elif (_num_zeros >= self.ASCII_pause - self.tolerance and
                                _num_zeros <= self.ASCII_pause + self.tolerance):
                              
                              if self.print_symbols:
                                  print("~")

                              # for further processing outside this block
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern(" "))

                              # marking detected ASCII pause
                              key = pmt.intern(" ")
                              value = pmt.intern("~")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect break pause
                          elif (_num_zeros >= self.break_pause - self.tolerance):
                              
                              if self.print_symbols:
                                  print(";")
                                  #print(f"symbol end, break")
                              
                              # for further processing outside this block 
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern(";"))
                              
                              # marking detected break pause
                              key = pmt.intern(" ")
                              value = pmt.intern("°")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          _num_zeros = 0
                  
                  # status: currently on
                  elif _sync == 1:
                      # status changes
                      if ch == 0:
                          _sync = 0
                          # WARN: this print is very slow, and may cause GNURadio to crash
                          if self.print_1duration:
                              print(f"#ones: {_num_ones}")
                          
                          # detect short symbol
                          if (_num_ones >= self.short_sym - self.tolerance and
                              _num_ones <= self.short_sym + self.tolerance):
                              
                              if self.print_symbols:
                                  print(f".", end="")
                              
                              # for further processing outside this block
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern("."))

                              # marking detected short symbol
                              key = pmt.intern(".")
                              value = pmt.intern(".")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          # detect long symbol
                          elif (_num_ones >= self.long_sym - self.tolerance and
                                _num_ones <= self.long_sym + self.tolerance):
                              
                              if self.print_symbols:
                                  print(f"_", end="")

                              # for further processing outside this block
                              self.message_port_pub(pmt.intern("msg_out"), pmt.intern("_"))

                              # marking detected long symbol
                              key = pmt.intern("_")
                              value = pmt.intern("_")
                              self.add_item_tag(0,
                                  self.nitems_written(0) + idx,
                                  key,
                                  value
                              )

                          _num_ones = 0

                      # status remains identical
                      elif ch == 1:
                          pass
                  
                  # reset zeros during longer pauses
                  if _num_zeros >= 200000:
                      _sync = -1
                      _num_zeros = 0
                      _num_ones = 0

                  # this should not happen anyway
                  if _num_ones >= 200000:
                      _sync = -1
                      _num_zeros = 0
                      _num_ones = 0

              # simply pass through original signal with tags attached
              output_items[0][:] = input_items[0]

              return len(output_items[0])
    break_pause: word_space
    comment: |-
      determines the morse
      symbols ".", "_", and
      symbol/word breaks
      with a certain tolerance
    long_sym: letter_space
    print_0duration: print_0duration
    print_1duration: print_1duration
    print_symbols: print_symbols
    short_sym: element_space
    tolerance: tolerance
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '8'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import zmq
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      several (mostly German) websites on Morse code and acronyms

      http://dk3red.homepage.t-online.de/de/s3_02.htm
      http://dk3red.homepage.t-online.de/de/s3.htm
      https://wiki.oevsv.at/wiki/Abk%C3%BCrzungen
      https://www.modellskipper.de/Maritimes/Abkuerzungen_Abschnitt_A/Index
      https://www.qsl.net/dk5ke/abk.html
      https://wiki.edu.vn/wiki18/2021/01/26/abkurzungen-fur-morsecodes-wikipedia/

      https://en.wikipedia.org/wiki/Morse_code_abbreviations
    note: Morse Abbreviations (German Translation)
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      35.7 – 137,8 kHz
      1810 – 1838 kHz
      3500 – 3570 kHz
      7000 – 7040 kHz
      10100 – 10130 kHz
      14000 – 14070 kHz
      18068 – 18095 kHz
      21000 – 21070 kHz
      24890 – 24915 kHz
      28000 – 28070 kHz
    note: permitted Morse frequencies
  states: {}
- name: note_1_1
  id: note
  parameters:
    comment: |-
      (Wikipedia)
      International Morse code is composed of five elements: 

       * short mark, dot or dit or ( ▄ ) or (.): "dit duration" is one time unit long = 1 tau
       * long mark, dash or dah or ( ▄▄▄ ) or (_): three time units long = 3 tau
       * element-space (^) between the marks within a character: one time unit long = 1 tau
       * letter-space: three time units long = 3 tau
       * word-space: seven time units long (formerly five) = 7 tau
    note: permitted Morse frequencies
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '30'
    bw0: '30000000'
    freq0: band_freq + freq_morse + freq_shift_corr
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '30'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: (1,0,1,3)
    key: freq
    label: CW band entry frequency
    type: int
    value: '7000000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color3: black
    comment: |-
      to view the adjustded
      gain, thresholder and tau
    gui_hint: (12,0,3,3)
    label1: envelope signal
    label2: threshold signal
    label3: high threshold
    label4: low threshold
    nconnections: '4'
    size: int(samp_rate/8)
    srate: int(samp_rate/32)
    type: float
    update_time: '0.025'
    ymax: '6'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1000'
    comment: |-
      helps the user to
      find and adjust
      active Morse
      signals
    fc: '0'
    fftsize: '512'
    grid: 'True'
    gui_hint: (5,0,5,3)
    name: Morse-Waterfall
    type: complex
    update_time: '0.025'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      especially to
      avoid overflows
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ server
      to futher decode the symbols
      to human-readible ASCII
      symbols and words
    timeout: '900'
  states: {}

connections:
- [analog_agc2_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '3']
- [analog_simple_squelch_cc_0_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', audio_sink_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0_0_0, '0']
- [check_box_print_0duration, state, blocks_msgpair_to_var_0_0_0, inpair]
- [checkbox_print_1duration, state, blocks_msgpair_to_var_0_0, inpair]
- [checkbox_print_symbols, state, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, '0', virtual_sink_1, '0']
- [epy_block_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0_0_0, msg_out, zeromq_push_msg_sink_1, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [osmosdr_source_0, '0', analog_agc2_xx_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_msgpair_to_var_0_1, inpair]
- [rational_resampler_xxx_0_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_1, '0', blocks_threshold_ff_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
